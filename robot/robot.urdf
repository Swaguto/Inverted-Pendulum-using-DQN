Commit message: Implement SAC training fix and update pendulum mass to 238g

File: robot/robot.urdf (robot description, URDF)
Before this commit: robot C:\Users\Rohith\--pendenv2\robot, 3 links, 2 joints
Links:
- link pendulum: mass 0.2 -> 0.238
